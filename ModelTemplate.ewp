# IAR project ModelTemplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Microchip ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DONT_USE_CMSIS_INIT; __SAMC21J18A__
  ICCARM.CCIncludePath2: ..\..\xdk-asf-3.49.1\thirdparty\CMSIS\Include; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\component; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\instance; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\pio; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\source\; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\source\iar; src; src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ModelTemplate.hex
  ILINK.IlinkOutputFile: ModelTemplate.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    src/: Init.c Main.c SystemHandler.c Tick.c
